# Keil uVision project WKUP.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WKUP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\WKUP;..\HARDWARE\OLED;..\HARDWARE\FDC2214;..\HARDWARE\IIC;..\HARDWARE\TIMER;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\FLASH;..\HARDWARE\SPI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/FDC2214/: FDC2214.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: mytime.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_spi.c
  group README
    ../: README.TXT
